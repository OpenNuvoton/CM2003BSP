# Keil uVision project CRC_CRC32_PDMA.uvprojx, settings and files
target CRC_CRC32_PDMA (6220000::V6.22::ARMCLANG)
  device: CM2003GN8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x9000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: CRC_CRC32_PDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\CM2003\Include;..\..\..\..\Library\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\CM2003\Source\ARM\APROM.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2003/Source/: system_CM2003.c
    ../../../../Library/Device/Nuvoton/CM2003/Source/ARM/: startup_CM2003.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c crc.c fmc.c pdma.c
  group User
    ../: main.c
  group ChipDef
    ../../../../Library/Device/Nuvoton/CM2003/Include/: chip_type.h
