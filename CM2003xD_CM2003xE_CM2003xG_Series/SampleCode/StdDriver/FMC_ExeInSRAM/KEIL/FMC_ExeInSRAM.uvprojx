# Keil uVision project FMC_ExeInSRAM.uvprojx, settings and files
target FMC_ExeInSRAM (6220000::V6.22::ARMCLANG)
  device: CM2003GN8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x9000) IROM(0x00000000,0x40000) IROM2(0x00100000,0x1000) IROM3(0x00200000,0x400) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_ExeInSRAM
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\..\Library\Device\Nuvoton\CM2003\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\scatter.scf
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2003/Source/: system_CM2003.c
    ./: startup_CM2003_user.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c fmc.c
  group ChipDef
    ../../../../Library/Device/Nuvoton/CM2003/Include/: chip_type.h
