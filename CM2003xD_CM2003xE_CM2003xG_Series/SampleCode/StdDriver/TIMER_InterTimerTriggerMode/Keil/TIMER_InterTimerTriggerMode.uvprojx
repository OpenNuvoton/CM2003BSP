# Keil uVision project TIMER_InterTimerTriggerMode.uvprojx, settings and files
target TIMER_InterTimerTriggerMode (6120000::V6.12::.\ARMCLANG)
  device: CM2003GN8AE Nuvoton
  pack: Nuvoton.NuMicroCM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x9000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: TIMER_InterTimerTriggerMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\CM2003\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x9000
  link misc: --map --first='startup_CM2003.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2003/Source/ARM/: startup_CM2003.s
    ../../../../Library/Device/Nuvoton/CM2003/Source/: system_CM2003.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c timer.c
  group User
    ../: main.c
  group ChipDef
    ../../../../Library/Device/Nuvoton/CM2003/Include/: chip_type.h
