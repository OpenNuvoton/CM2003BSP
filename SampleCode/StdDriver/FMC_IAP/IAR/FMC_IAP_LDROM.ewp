# IAR project FMC_IAP_LDROM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CM2003 series Nuvoton CM2003 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\CM2003\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\FMC_IAP_LDROM.bin
  ILINK.IlinkOutputFile: FMC_IAP_LDROM.out
  ILINK.IlinkIcfFile: FMC_IAP_LDROM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2003/Source/IAR/: startup_CM2003.s
    ../../../../Library/Device/Nuvoton/CM2003/Source/: system_CM2003.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: FMC_IAP_LDROM.c
