# Keil uVision project FMC_MultiBoot.uvprojx, settings and files
target FMC_MultiBoot (6120000::V6.12::.\ARMCLANG)
  device: CM2003FC1AE Nuvoton
  pack: Nuvoton.NuMicroCM_DFP.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: FMC_MultiBoot
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __BASE__
  c include: ..\..\..\..\Library\Device\Nuvoton\CM2003\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_CM2003_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/CM2003/Source/: system_CM2003.c
    ./: startup_CM2003_user.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c sys.c uart.c
target FMC_Boot0 (6120000::V6.12::.\ARMCLANG)
  device: CM2003FC1AE Nuvoton
  pack: Nuvoton.NuMicroCM_DFP.1.0.0
  cpu: as above
  output: FMC_Boot0
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT0__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: as above
target FMC_Boot1 (6120000::V6.12::.\ARMCLANG)
  device: CM2003FC1AE Nuvoton
  pack: Nuvoton.NuMicroCM_DFP.1.0.0
  cpu: as above
  output: FMC_Boot1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT1__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: as above
target FMC_Boot2 (6120000::V6.12::.\ARMCLANG)
  device: CM2003FC1AE Nuvoton
  pack: Nuvoton.NuMicroCM_DFP.1.0.0
  cpu: as above
  output: FMC_Boot2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __BOOT2__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: as above
target FMC_BootLD (6120000::V6.12::.\ARMCLANG)
  device: CM2003FC1AE Nuvoton
  pack: Nuvoton.NuMicroCM_DFP.1.0.0
  cpu: as above
  output: FMC_BootLD
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=1
  c define: __LDROM__
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: as above
